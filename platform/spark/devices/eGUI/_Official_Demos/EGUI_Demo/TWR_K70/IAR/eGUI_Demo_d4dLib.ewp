# IAR project eGUI_Demo_d4dLib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK70FN1M0xxx12 Freescale MK70FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: $_MQX_PATH_$\lib\twrk70f120m.iar\debug\bsp; $_MQX_PATH_$\lib\twrk70f120m.iar\debug\bsp\Generated_Code; $_MQX_PATH_$\lib\twrk70f120m.iar\debug\psp; $_MQX_PATH_$\lib\twrk70f120m.iar\debug\mfs; $_MQX_PATH_$\lib\twrk70f120m.iar\debug; ..\..\..\..\D4D; D4D_Configuration
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  postbuild: "post_built_d.bat" "$PROJ_DIR$"
  ILINK.IlinkOutputFile: CompDemoGUI_d4dLib.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: $_MQX_PATH_$\lib\twrk70f120m.iar\release\bsp; $_MQX_PATH_$\lib\twrk70f120m.iar\release\bsp\dbg; $_MQX_PATH_$\lib\twrk70f120m.iar\release\bsp\Generated_Code; $_MQX_PATH_$\lib\twrk70f120m.iar\release\psp; $_MQX_PATH_$\lib\twrk70f120m.iar\release\mfs; $_MQX_PATH_$\lib\twrk70f120m.iar\release; ..\..\..\..\D4D; D4D_Configuration
  ICCARM.CCOptLevel: 3
  postbuild: "post_built.bat" "$PROJ_DIR$"
  group D4D
    ../../../../D4D/: d4d.h
  group D4D/common_source
    ../../../../D4D/common_files/: d4d_base.c d4d_base.h d4d_basic_draw.c d4d_basic_draw.h d4d_bmp.c d4d_bmp.h d4d_extsrc.c d4d_extsrc.h d4d_font.c d4d_font.h d4d_imgdec_bmp.c d4d_imgdec_bmp.h d4d_imgdec_d4d.c d4d_imgdec_d4d.h d4d_imgdec_d4dint.c d4d_imgdec_d4dint.h d4d_lldapi.h d4d_low.c d4d_low.h d4d_math.c d4d_math.h d4d_mouse.c d4d_mouse.h d4d_object.c d4d_object.h d4d_private.h d4d_scheme.c d4d_scheme.h d4d_screen.c d4d_screen.h d4d_string.c d4d_string.h d4d_types.h
  group D4D/graphic_objects
    ../../../../D4D/graphic_objects/: d4d_button.c d4d_button.h d4d_check_box.c d4d_check_box.h d4d_combo_box.c d4d_combo_box.h d4d_console.c d4d_console.h d4d_edit_box.c d4d_edit_box.h d4d_gauge.c d4d_gauge.h d4d_graph.c d4d_graph.h d4d_group_box.c d4d_group_box.h d4d_icon.c d4d_icon.h d4d_label.c d4d_label.h d4d_list_box.c d4d_list_box.h d4d_menu.c d4d_menu.h d4d_picture.c d4d_picture.h d4d_progress_bar.c d4d_progress_bar.h d4d_radio_button.c d4d_radio_button.h d4d_scroll_bar.c d4d_scroll_bar.h d4d_slider.c d4d_slider.h d4d_text_box.c d4d_text_box.h
  group D4D/low_level_drivers/LCD/lcd_controllers_drivers/frame_buffer
    ../../../../D4D/low_level_drivers/LCD/lcd_controllers_drivers/frame_buffer/: d4dlcd_frame_buffer.c d4dlcd_frame_buffer.h
  group D4D/low_level_drivers/LCD/lcd_hw_interface/common_drivers
    ../../../../D4D/low_level_drivers/LCD/lcd_hw_interface/common_drivers/: d4dlcdhw_common.c d4dlcdhw_common.h
  group D4D/low_level_drivers/LCD/lcd_hw_interface/k70_lcdc
    ../../../../D4D/low_level_drivers/LCD/lcd_hw_interface/k70_lcdc/: d4dlcdhw_k70_lcdc.c d4dlcdhw_k70_lcdc.h
  group D4D/low_level_drivers/LCD/lcd_hw_interface/k70_lcdc/twr_rgb_rev_b
    ../../../../D4D/low_level_drivers/LCD/lcd_hw_interface/k70_lcdc/twr_rgb_rev_b/: d4dlcdhw_twrrgbb.c d4dlcdhw_twrrgbb.h
  group D4D/low_level_drivers/touch_screen/touch_screen_drivers/cr_touch
    ../../../../D4D/low_level_drivers/touch_screen/touch_screen_drivers/cr_touch/: d4dtch_cr_touch.c d4dtch_cr_touch.h hw_iic_cfg.h mqx_iic_cfg.h
  group D4D/low_level_drivers/touch_screen/touch_screen_drivers/cr_touch/iic
    ../../../../D4D/low_level_drivers/touch_screen/touch_screen_drivers/cr_touch/iic/: hw_iic.c hw_iic.h hw_iic_prv.h
  group D4D/low_level_drivers/touch_screen/touch_screen_drivers/cr_touch/iic_mqx
    ../../../../D4D/low_level_drivers/touch_screen/touch_screen_drivers/cr_touch/iic_mqx/: mqx_iic.c mqx_iic.h
  group D4D_Configuration
    D4D_Configuration/: d4d_user_cfg.h d4dlcd_frame_buffer_cfg.h d4dlcdhw_k70_lcdc_cfg.h d4dtch_cr_touch_cfg.h
    ../../common_sources/: d4d_user_cfg_app.h
