# IAR project egui_twrk60.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: $_MQX_PATH_$\lib\twrk60d100m.iar\debug\bsp; $_MQX_PATH_$\lib\twrk60d100m.iar\debug\bsp\Generated_Code; $_MQX_PATH_$\lib\twrk60d100m.iar\debug\psp; $_MQX_PATH_$\lib\twrk60d100m.iar\debug; ; ..\..\..\..\..\D4D; ..\..\..\common_source; ..\..\..\mqx_demo
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: egui_twrk60.srec
  ILINK.IlinkOutputFile: egui_twrk60.out
  ILINK.IlinkIcfFile: $_MQX_PATH_$\lib\twrk60d100m.iar\debug\bsp\intflash.icf
  ILINK.IlinkAdditionalLibs: $_MQX_PATH_$\lib\twrk60d100m.iar\debug\psp\psp.a; $_MQX_PATH_$\lib\twrk60d100m.iar\debug\bsp\bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: $_MQX_PATH_$\lib\twrk60d100m.iar\Release\bsp; $_MQX_PATH_$\lib\twrk60d100m.iar\Release\bsp\Generated_Code; $_MQX_PATH_$\lib\twrk60d100m.iar\Release\psp; $_MQX_PATH_$\lib\twrk60d100m.iar\Release; ; ..\..\..\..\..\D4D; ..\..\..\common_source; ..\..\..\mqx_demo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ILINK.IlinkIcfFile: $_MQX_PATH_$\lib\twrk60d100m.iar\Release\bsp\intflash.icf
  ILINK.IlinkAdditionalLibs: $_MQX_PATH_$\lib\twrk60d100m.iar\Release\psp\psp.a; $_MQX_PATH_$\lib\twrk60d100m.iar\Release\bsp\bsp.a
  group D4D
    ../../../../../D4D/: d4d.h
  group D4D/common_files
    ../../../../../D4D/common_files/: d4d_base.c d4d_base.h d4d_basic_draw.c d4d_basic_draw.h d4d_bmp.c d4d_bmp.h d4d_extsrc.c d4d_extsrc.h d4d_font.c d4d_font.h d4d_imgdec_bmp.c d4d_imgdec_bmp.h d4d_imgdec_d4d.c d4d_imgdec_d4d.h d4d_imgdec_d4dint.c d4d_imgdec_d4dint.h d4d_lldapi.h d4d_low.c d4d_low.h d4d_math.c d4d_math.h d4d_object.c d4d_object.h d4d_private.h d4d_scheme.c d4d_scheme.h d4d_screen.c d4d_screen.h d4d_string.c d4d_string.h d4d_types.h
  group D4D/graphic_objects
    ../../../../../D4D/graphic_objects/: d4d_button.c d4d_button.h d4d_check_box.c d4d_check_box.h d4d_console.c d4d_console.h d4d_edit_box.c d4d_edit_box.h d4d_gauge.c d4d_gauge.h d4d_graph.c d4d_graph.h d4d_group_box.c d4d_group_box.h d4d_icon.c d4d_icon.h d4d_label.c d4d_label.h d4d_list_box.c d4d_list_box.h d4d_menu.c d4d_menu.h d4d_picture.c d4d_picture.h d4d_progress_bar.c d4d_progress_bar.h d4d_radio_button.c d4d_radio_button.h d4d_scroll_bar.c d4d_scroll_bar.h d4d_slider.c d4d_slider.h d4d_text_box.c d4d_text_box.h
  group D4D/low_level_drivers/LCD/lcd_controller_drivers/ssd1289
    ../../../../../D4D/low_level_drivers/LCD/lcd_controllers_drivers/ssd1289/: d4dlcd_SSD1289.c d4dlcd_SSD1289.h
  group D4D/low_level_drivers/LCD/lcd_hw_interface/common_drivers
    ../../../../../D4D/low_level_drivers/LCD/lcd_hw_interface/common_drivers/: d4dlcdhw_common.c d4dlcdhw_common.h
  group D4D/low_level_drivers/LCD/lcd_hw_interface/mqx_flexbus
    ../../../../../D4D/low_level_drivers/LCD/lcd_hw_interface/mqx_flexbus/: d4dlcdhw_mqx_fb.c
  group D4D/low_level_drivers/LCD/lcd_hw_interface/mqx_spi
    ../../../../../D4D/low_level_drivers/LCD/lcd_hw_interface/mqx_spi/: d4dlcdhw_mqx_spi.c
  group D4D/low_level_drivers/touch_screen/touch_screen_drivers/resistive
    ../../../../../D4D/low_level_drivers/touch_screen/touch_screen_drivers/resistive/: d4dtch_resistive.c d4dtch_resistive.h
  group D4D/low_level_drivers/touch_screen/touch_screen_drivers/resistive_mqx
    ../../../../../D4D/low_level_drivers/touch_screen/touch_screen_drivers/resistive_mqx/: d4dtch_resistive_mqx.c d4dtch_resistive_mqx.h
  group D4D_Configuration
    ../../../mqx_demo/: d4d_user_cfg.h
  group Sources/common_source
    ../../../common_source/: d4d_screen_about.c d4d_screen_entry.c d4d_screen_log.c d4d_screen_log.h d4d_screen_main.c d4d_screen_winmenu.c d4d_user_cfg_app.h fonts.c fonts.h pictures.c pictures.h
  group Sources/project
    ../../../mqx_demo/: main.c main.h
