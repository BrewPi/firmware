# IAR project eGUI_Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK70FN1M0xxx15 Freescale MK70FN1M0xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: $_MQX_PATH_$\lib\twrk70f120m.iar\debug\bsp; $_MQX_PATH_$\lib\twrk70f120m.iar\debug\bsp\Generated_Code; $_MQX_PATH_$\lib\twrk70f120m.iar\debug\psp; $_MQX_PATH_$\lib\twrk70f120m.iar\debug\mfs; $_MQX_PATH_$\lib\twrk70f120m.iar\debug\shell; $_MQX_PATH_$\lib\twrk70f120m.iar\debug\usb; $_MQX_PATH_$\lib\twrk70f120m.iar\debug; $_MQX_PATH_$\mqx\source\psp\cortex; $_MQX_PATH_$\mqx\source\include; ..\..\common_sources; D4D_LIBRARY
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CompDemoGUI.srec
  ILINK.IlinkOutputFile: eGUI_Demo_d.out
  ILINK.IlinkIcfFile: $_MQX_PATH_$\lib\twrk70f120m.iar\debug\bsp\intflash_ddrdata.icf
  ILINK.IlinkAdditionalLibs: $_MQX_PATH_$\lib\twrk70f120m.iar\debug\bsp\bsp.a; $_MQX_PATH_$\lib\twrk70f120m.iar\debug\psp\psp.a; $_MQX_PATH_$\lib\twrk70f120m.iar\debug\mfs\mfs.a; $_MQX_PATH_$\lib\twrk70f120m.iar\debug\usb\usbh.a; D4D_LIBRARY\eGUI_Demo_d4dLib_d.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: $_MQX_PATH_$\lib\twrk70f120m.iar\release\bsp; $_MQX_PATH_$\lib\twrk70f120m.iar\release\bsp\dbg; $_MQX_PATH_$\lib\twrk70f120m.iar\release\bsp\Generated_Code; $_MQX_PATH_$\lib\twrk70f120m.iar\release\psp; $_MQX_PATH_$\lib\twrk70f120m.iar\release\mfs; $_MQX_PATH_$\lib\twrk70f120m.iar\release\shell; $_MQX_PATH_$\lib\twrk70f120m.iar\release\usb; $_MQX_PATH_$\lib\twrk70f120m.iar\release; $_MQX_PATH_$\mqx\source\psp\cortex; $_MQX_PATH_$\mqx\source\include; ..\..\common_sources; D4D_LIBRARY
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: $_MQX_PATH_$\lib\twrk70f120m.iar\release\bsp\intflash_ddrdata.icf
  ILINK.IlinkAdditionalLibs: $_MQX_PATH_$\lib\twrk70f120m.iar\release\bsp\bsp.a; $_MQX_PATH_$\lib\twrk70f120m.iar\release\psp\psp.a; $_MQX_PATH_$\lib\twrk70f120m.iar\release\mfs\mfs.a; $_MQX_PATH_$\lib\twrk70f120m.iar\release\usb\usbh.a; D4D_LIBRARY\eGUI_Demo_d4dLib.a
  group Sources
    ../../common_sources/: main.c main.h
  group Sources/ScreenData
    ../../common_sources/: fonts.c fonts.h pictures.c pictures.h strings.c strings.h
  group Sources/Screens
    ../../common_sources/: d4d_screen_main.c d4d_screen_openfile.c d4d_screen_openfile.h d4d_screen_scrsvr.c d4d_screen_settings.c
  group Sources/Support
    ../../common_sources/: file_list.c file_list.h hidkeyboard.c hidkeyboard.h hidmouse.c hidmouse.h sd_card.c usb_classes.c usb_classes.h usbh_hid.c
